<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PRJ_STM8_PUSH5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


